# Keil uVision project board_test.uvprojx, settings and files
target Debug In Flash (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: NXP.LPC54114_DFP.10.0.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: board_test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_LPC54114J256BD64_cm4, USB_STACK_BM
  c include: ..\app;..\bsp;..\csp;..\fatfs\fatfs_0.11a\src;..\usbd\usb_1.2.0\include;..\usbd\usb_1.2.0\device;..\usbd\usb_1.2.0\osa;..\usbd\usb_1.2.0\usr_class
  asm define: CPU_LPC54114J256_M4, DEBUG,__CC_ARM,KEIL
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\csp\LPC54114J256_cm4.scf
  group app
    ../app/: application.c app_led.c app_interrupt.c app_adc.c app_key.c app_dmic.c app_spiflash.c app_pct2075.c app_spiSD.c app_wm8904.c app_usbdmsc.c
  group csp
    ../csp/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_debug_console.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2c_freertos.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_notifier.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sbrk.c fsl_sctimer.c fsl_shell.c fsl_spi.c fsl_spi_dma.c fsl_spi_freertos.c fsl_usart.c fsl_usart_dma.c fsl_usart_freertos.c fsl_utick.c fsl_wwdt.c system_LPC54114_cm4.c keil_lib_power.lib startup_LPC54114_cm4.s
  group bsp
    ../bsp/: board.c clock_config.c pin_mux.c
  group fat
    ../fatfs/fatfs_0.11a/src/: diskio.c ff.c
  group usb
    ../usbd/usb_1.2.0/device/: usb_device_lpcip3511.c usb_device_dci.c
    ../usbd/usb_1.2.0/osa/: usb_osa_bm.c
    ../usbd/usb_1.2.0/usr_class/: usb_device_ch9.c usb_device_class.c usb_device_descriptor.c usb_device_msc.c usb_device_msc_ufi.c
software components: Compiler:I/O:STDOUT 1.4.0
